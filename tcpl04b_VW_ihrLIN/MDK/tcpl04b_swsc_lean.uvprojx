# Keil uVision project tcpl04b_swsc_lean.uvprojx, settings and files
target swsc_normal (6210000::V6.21::ARMCLANG)
  device: TCPL04 TinyChip
  pack: TinyChip.TCxx_DFP.1.2.1
  cpu: IRAM(0x10000000,0x01000) IROM(0x00000000,0x0BC00) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: tcpl04b_swsc_lean +hex
  AfterMake: fromelf --bin --output "..\Build\Bin\tcpl04b_swsc_lean.bin" "#L"
  c flags: Optim=7 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __TCPL04X__,__TCPL04B__,MULTI_BYTES_MODE
  c include: .\01_ASW\01_Integration;.\01_ASW\02_Swc_Lighting;.\01_ASW\03_Swc_Diagnostic;.\01_ASW\04_Algorithm;.\02_RTE;.\04_BSW_COM;.\03_BSW_UDS;.\11_Vendor_SDK\IHR\Generated;.\11_Vendor_SDK\IHR\Protocol;.\13_Common;.\05_BSW_NVM;.\06_BSW_DEM;.\07_BSW_SYSTEM;.\08_BSW_ECUAL;.\09_MCAL;.\10_Device;.\11_Vendor_SDK;.\12_Config
  asm include: .\01_ASW\01_Integration;.\01_ASW\02_Swc_Lighting;.\01_ASW\03_Swc_Diagnostic;.\01_ASW\04_Algorithm;.\02_RTE;.\03_BSW_UDS;.\04_BSW_COM;.\05_BSW_NVM;.\06_BSW_DEM;.\07_BSW_SYSTEM;.\08_BSW_ECUAL;.\09_MCAL;.\10_Device;.\11_Vendor_SDK;.\12_Config;.\13_Common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xbc00
  memory RVCT9: RAM 0x10000000 size 0x1000
  scatter file: .\tcpl04b_normal.sct
  link misc: --entry Reset_Handler
  group 01_ASW
    ./01_ASW/01_Integration/: EcuM_Callout.c
    ./01_ASW/02_Swc_Lighting/: Swc_LightControl.c Swc_Derating.c Swc_Communication.c Swc_Lighting.c Swc_Status.c Swc_Types.c Swc_PersistentData.c
    ./01_ASW/03_Swc_Diagnostic/: Swc_Diagnostic.c
    ./01_ASW/04_Algorithm/: Algorithm.c FixedPoint.c
  group 02_RTE
    ./02_RTE/: Rte_Com.c Rte_Bsw.c Rte_NvM.c Rte_Dem.c
  group 03_BSW_UDS
    ./03_BSW_UDS/: Dcm.c Dcm_LinNodeConfig.c LinTp.c
  group 04_BSW_COM
    ./04_BSW_COM/: Com.c LinIf.c LinIf_Init.c LinIf_Compat.c LinIf_Cfg.c
  group 05_BSW_NVM
    ./05_BSW_NVM/: NvM.c NvM_Cfg.c MemIf.c Fee.c
  group 06_BSW_DEM
    ./06_BSW_DEM/: Dem.c Dem_Cfg.c
  group 07_BSW_SYSTEM
    ./07_BSW_SYSTEM/: EcuM.c BswM.c
  group 08_BSW_ECUAL
    ./08_BSW_ECUAL/: IoHwAb_Adc.c IoHwAb_Battery.c IoHwAb_Time.c IoHwAb_Led.c IoHwAb_Temperature.c IoHwAb_Wdg.c
  group 09_MCAL
    ./09_MCAL/: Lin.c Lin_Hw.c Adc.c Fls.c Mcu.c
  group 10_Device
    ./10_Device/: system_tcpl04x.c startup_tcpl04x.s
  group 11_Vendor_SDK
    ./11_Vendor_SDK/: tcpl04x_ll_adc.c tcpl04x_ll_cortex.c tcpl04x_ll_flash.c tcpl04x_ll_flash_drv.c tcpl04x_ll_gpio.c tcpl04x_ll_led.c tcpl04x_ll_pwm.c tcpl04x_ll_sci.c tcpl04x_ll_sys.c tcpl04x_ll_wdg.c pal_led.c pal_lin_comm.c pal_store.c pal_wdg.c utilities.c
target swsc_match_boot (6130001::V6.13.1::.\ARMCLANG)
  device: TCPL04 TinyChip
  pack: TinyChip.TCxx_DFP.1.2.1
  cpu: IRAM(0x10000000,0x01000) IROM(0x00002000,0x09800) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: tcpl04b_swsc_lean_boot +hex
  AfterMake: fromelf --bin --output "..\Build\Bin\tcpl04b_swsc_lean_boot.bin" "#L"
  c flags: as above
  c define: __TCPL04X__,__TCPL04B__,APP_MATCH_BOOT,MULTI_BYTES_MODE
  c include: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x1000
  scatter file: .\tcpl04b_match_boot.sct
  link misc: --entry Reset_Handler
