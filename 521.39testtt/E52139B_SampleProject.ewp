# IAR project E52139B_SampleProject.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430_EL_E52139B EL_E52139B
  General.GStackSize2: 160
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: EL_DEVICE_E52139B
  ICC430.newCCIncludePaths: ; elmos/includes/; elmos/irq/E52139B/; elmos/LINDrv/includes/; elmos/LINDrv/includes/interfaces/; elmos/LINDrv/devices/E52139B/; elmos/LINDrv/devices/E52139B/Bus/; elmos/ROMInterface; elmos/ROMInterface/E52139B; elmos/modules/eeprom_access/16bit/52139/includes; elmos/modules/flash_access/16bit/52139/includes; modules/; System/; Algorithm/; lin_driver/; user/
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: lnkEL_E52139B.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    ./: lin_user.c lin_user.h LinDrvImp_Callbacks.c LinDrvImp_Callbacks.h LinDrvImp_CompilationConfig.h LinDrvImp_Config.c LinDrvImp_Config.h LinDrvImp_FrameConfig.c LinDrvImp_FrameConfig.h LinSNPDProxyLED_Implementation.c LinSNPDProxyLED_Implementation.h lnkEL_E52139B.xcl main.c
  group Algorithm
    Algorithm/: Algorithm.c Algorithm.h FloatLib.c FloatLib.h
  group elmos/includes
    elmos/includes/: el_helper_H430_IAR.c el_helper_H430_IAR.h el_types.h el_types_H430_IAR.h elmos_esw_global_MISRA.h io_e52139a.h io_e52139a_IAR.h io_e52139a_macros.h io_e52139b.h io_e52139b_IAR.h io_e52139b_macros.h
  group elmos/irq/E52139B
    elmos/irq/E52139B/: CommonInterruptHandler.c CommonInterruptHandler.h gpio_InterruptHandler.c gpio_InterruptHandler.h lin_ctrl_InterruptHandler.c lin_ctrl_InterruptHandler.h linsci_InterruptHandler.c linsci_InterruptHandler.h swtimer_InterruptHandler.c swtimer_InterruptHandler.h vic_Interface.h vic_InterruptHandler.c vic_InterruptHandler.h
  group elmos/LINDrv/source
    elmos/LINDrv/source/: LinDiag_Implementation.c
  group elmos/ROMInterface
    elmos/RomInterface/E52139B/: rom_API.c
  group modules
    modules/: mod_crc16.c mod_crc16.h mod_divider.c mod_divider.h mod_mul.c mod_mul.h mod_nvm.c mod_nvm.h mod_pwm.c mod_pwm.h ModuleAdc.c ModuleAdc.h ModuleBattery.c ModuleBattery.h ModuleClock.c ModuleClock.h ModuleFlash.c ModuleFlash.h ModuleLed.c ModuleLed.h ModulePower.c ModulePower.h ModuleTemperature.c ModuleTemperature.h ModuleWatchdog.c ModuleWatchdog.h
  group System
    System/: GeneralType.h genLinConfig.h SystemControl.c SystemControl.h SystemDerating.c SystemDerating.h SystemLinComm.c SystemLinComm.h SystemLinDiag.c SystemLinDiag.h SystemMain.c SystemMain.h SystemStatus.c SystemStatus.h SystemType.c SystemType.h
