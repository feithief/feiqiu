# Keil uVision project AmbientRGB_LINAA_TLD4020.uvprojx, settings and files
target AmbientRGB_LINAA_TLD4020 (6210000::V6.21::ARMCLANG)
  device: TLD4020-3ET Infineon
  pack: Infineon.TLD40xx_DFP.3.2.0-plus
  cpu: IRAM(0x18000000,0x0C00) IROM(0x12000000,0x7800) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: AmbientRGB_LINAA_TLD4020 +hex
  AfterMake: findstr /C:"Total R" Listings\*.map
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c include: .\App;.\Generated;.\Hal;.\Protocol;.\AA;.\System;.\modules;.\dimming;.\Algorithm;.\App;.\Protocol
  memory RVCT4: ROM 0x12000000 size 0x7600
  memory RVCT9: RAM 0x18000000 size 0xc00
  group App
    ./App/: LINApplication.c main.c lin_app.c
  group Generated
    ./Generated/: genLinConfig.c
  group Hal
    ./Hal/: lin_hal.c
  group Protocol
    ./Protocol/: lin_config.c lin_diag_raw.c lin_diag_tp.c lin_driver_api.c lin_main.c lin_master_task.c lin_slave_task.c
  group AA
    ./AA/: lin_autoaddressing.c
  group System
    ./System/: SystemControl.c SystemDerating.c SystemLinComm.c SystemLinDiag.c SystemMain.c SystemStatus.c SystemType.c
  group Modules
    ./modules/: ModuleAdc.c ModuleBattery.c ModuleClock.c ModuleFlash.c ModuleLed.c ModulePower.c ModuleTemperature.c
  group dimming
    ./dimming/: BINARYSEARCH_U16.c Dimming_Calculate.c INTERPOLATE_U16_U16.c LookUp_U16_U16.c
  group Algorithm
    ./Algorithm/: Algorithm.c FloatLib.c
software components: CMSIS:CORE 5.5.0, Device:Config Wizard 1.1.0, Device:Lib:ADC11 1.0.2, Device:Lib:BOOTROM 1.0.0, Device:Lib:CPU 1.0.1, Device:Lib:GPIO 1.0.1, Device:Lib:ISR 1.0.2, Device:Lib:LDRV 1.0.2, Device:Lib:LIN 2.0.2, Device:Lib:MEM 1.0.1, Device:Lib:OSC 1.0.1, Device:Lib:PMU 1.0.1, Device:Lib:SCU 1.0.1, Device:Startup:Startup files 1.0.0
