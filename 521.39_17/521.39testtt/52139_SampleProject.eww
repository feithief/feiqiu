<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\E52139B_SampleProject.ewp</path>
  </project>
  <batchBuild/>
</workspace>


