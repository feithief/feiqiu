# Keil uVision project TLD4020_3ET_1000TP_PROGRAMMING.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: TLD4020-3ET Infineon
  pack: Infineon.TLD40xx_DFP.3.2.0-plus
  cpu: IRAM(0x18000000,0x0C00) IROM(0x12000000,0x7800) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: TLD4020_3ET_1000TP_PROGRAMMING
  AfterMake: findstr /C:"Total R" Listings\*.map
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -Wno-unsafe-buffer-usage -Wno-covered-switch-default
  memory RVCT4: ROM 0x12000000 size 0x7800
  memory RVCT9: RAM 0x18000000 size 0xc00
  scatter file: .\RTE\Device\TLD4020-3ET\tld40xx.sct
  group Source Group 1
    ./app/: main.c
software components: CMSIS:CORE 5.6.0, Device:Config Wizard 1.1.0, Device:Lib:ADC11 1.0.2, Device:Lib:BOOTROM 1.0.0, Device:Lib:CPU 1.0.1, Device:Lib:GPIO 1.0.1, Device:Lib:ISR 1.0.2, Device:Lib:LDRV 1.0.2, Device:Lib:MEM 1.0.1, Device:Lib:PMU 1.0.1, Device:Lib:SCU 1.0.1, Device:Startup 1.0.0
