# IAR project TLD4020_3ET_1000TP_PROGRAMMING.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TLD4020-3ET Infineon TLD4020-3ET
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 60
  General.FPU2: 0
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ILINK.IlinkOutputFile: TLD4020_3ET_1000TP_PROGRAMMING.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group app
    app/: main.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/Device Config Wizard
    RTE/Device/TLD4020-3ET/: adc11_defines.h bsl_defines.h config.icwp cpu_defines.h gpio_defines.h icw_cmt.xml icw_cmt_adc11.xml icw_cmt_bsl.xml icw_cmt_cpu.xml icw_cmt_gpio.xml icw_cmt_ldrv.xml icw_cmt_lin.xml icw_cmt_mem.xml icw_cmt_pmu.xml icw_cmt_scu.xml isr_defines.h ldrv.py ldrv_defines.h lin_defines.h mem_defines.h pmu_defines.h scu_defines.h tld40xx.svd
  group CMSIS-Pack/Device Startup
    RTE/Device/TLD4020-3ET/: cmsis_misra.h device.c device.h error_codes.h startup_tld40xx.c system_tld40xx.c system_tld40xx.h tld40xx.h tld40xx.icf types.h variants.h
  group CMSIS-Pack/Device.Lib ADC11
    RTE/Device/TLD4020-3ET/: adc11.c adc11.h
  group CMSIS-Pack/Device.Lib BOOTROM
    RTE/Device/TLD4020-3ET/: bootrom.h
  group CMSIS-Pack/Device.Lib CPU
    RTE/Device/TLD4020-3ET/: cpu.c cpu.h
  group CMSIS-Pack/Device.Lib GPIO
    RTE/Device/TLD4020-3ET/: gpio.c gpio.h
  group CMSIS-Pack/Device.Lib ISR
    RTE/Device/TLD4020-3ET/: isr.c isr.h isr_nvic_irq0_handler.c isr_nvic_irq0_handler.h isr_nvic_irq2_handler.c isr_nvic_irq2_handler.h isr_nvic_irq4_handler.c isr_nvic_irq4_handler.h isr_nvic_irq5_handler.c isr_nvic_irq5_handler.h isr_nvic_irq6_handler.c isr_nvic_irq6_handler.h isr_nvic_irq7_handler.c isr_nvic_irq7_handler.h
  group CMSIS-Pack/Device.Lib LDRV
    RTE/Device/TLD4020-3ET/: ldrv.c ldrv.h
  group CMSIS-Pack/Device.Lib LIN
    RTE/Device/TLD4020-3ET/: lin.c lin.h
  group CMSIS-Pack/Device.Lib MEM
    RTE/Device/TLD4020-3ET/: mem.c mem.h
  group CMSIS-Pack/Device.Lib PMU
    RTE/Device/TLD4020-3ET/: pmu.c pmu.h
  group CMSIS-Pack/Device.Lib SCU
    RTE/Device/TLD4020-3ET/: scu.c scu.h
