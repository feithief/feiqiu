# Keil uVision project SWSC_Application.uvprojx, settings and files
target SWSC_Application (6210000::V6.21::ARMCLANG)
  device: TLD4020-3ET Infineon
  pack: Infineon.TLD40xx_DFP.2.0.1
  cpu: IRAM(0x18000000,0x0C00) IROM(0x12000000,0x7800) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: SWSC_Application +hex
  AfterMake: findstr /C:"Total R" Listings\*.map
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c include: .\Config;.\App;.\Generated;.\Hal;.\Protocol;.\AA;.\System;.\modules;.\dimming;.\Algorithm;.\PublicInclude;.\RTE;.\RTE\Device\TLD4020-3ET;.\RTE\_AmbientRGB_LINAA_TLD4020
  memory RVCT4: ROM 0x12000000 size 0x7600
  memory RVCT9: RAM 0x18000000 size 0xc00
  group Config (external)
    ./Config/: lin_autoaddressing_cfg.c lin_autoaddressing_cfg.h
  group App
    ./App/: LINApplication.c main.c lin_app.c
  group Generated
    ./Generated/: genLinConfig.c
  group Hal
    ./Hal/: lin_hal.c
  group Protocol
    ./Protocol/: lin_config.c lin_diag_raw.c lin_diag_tp.c lin_driver_api.c lin_main.c lin_master_task.c lin_slave_task.c
  group AA
    ./AA/: lin_autoaddressing.c
  group System
    ./System/: SystemControl.c SystemDerating.c SystemLinComm.c SystemLinDiag.c SystemMain.c SystemStatus.c SystemType.c
  group Modules
    ./modules/: ModuleAdc.c ModuleBattery.c ModuleClock.c ModuleFlash.c ModuleLed.c ModulePower.c ModuleTemperature.c
  group dimming
    ./dimming/: BINARYSEARCH_U16.c Dimming_Calculate.c INTERPOLATE_U16_U16.c LookUp_U16_U16.c
  group Algorithm
    ./Algorithm/: Algorithm.c FloatLib.c
  group Public Headers
    ./PublicInclude/: Algorithm.h BINARYSEARCH_U16.h Dimming_Calculate.h Dimming_Calculate_Fun.h eeprom_access.h eeprom_access_interface.h flash.h flash_access.h flash_access_interface.h flash_access_types.h FloatLib.h GeneralType.h genLinConfig.h INTERPOLATE_U16_U16.h lin_app.h lin_autoaddressing.h lin_config.h lin_diag_raw.h lin_diag_tp.h lin_driver_api.h lin_hal.h lin_main.h lin_master_task.h lin_slave_task.h lin_type.h LINApplication.h LookUp_U16_U16.h main.h mod_crc16.h mod_divider.h mod_mul.h mod_nvm.h mod_pwm.h ModuleAdc.h ModuleBattery.h ModuleClock.h ModuleFlash.h ModuleLed.h ModulePower.h ModuleTemperature.h ModuleWatchdog.h rtwtypes.h SystemControl.h SystemDerating.h SystemLinComm.h SystemLinDiag.h SystemMain.h SystemStatus.h SystemType.h
software components: CMSIS:CORE 5.5.0, Device:Config Wizard 1.1.0, Device:Lib:ADC11 1.0.2, Device:Lib:BOOTROM 1.0.0, Device:Lib:CPU 1.0.1, Device:Lib:GPIO 1.0.1, Device:Lib:ISR 1.0.2, Device:Lib:LDRV 1.0.2, Device:Lib:LIN 2.0.2, Device:Lib:MEM 1.0.1, Device:Lib:OSC 1.0.1, Device:Lib:PMU 1.0.1, Device:Lib:SCU 1.0.1, Device:Startup:Startup files 1.0.0
