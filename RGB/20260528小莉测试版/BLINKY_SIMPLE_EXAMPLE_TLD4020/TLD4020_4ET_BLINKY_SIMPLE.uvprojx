# Keil uVision project TLD4020_4ET_BLINKY_SIMPLE.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: TLD4020-4ET Infineon
  pack: Infineon.TLD40xx_DFP.3.2.0-plus
  cpu: IRAM(0x18000000,0x0C00) IROM(0x12000000,0x7600) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: TLD4020_4ET_JLINK_GETTING_STARTED +hex
  AfterMake: findstr /C:"Total R" Listings\*.map
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=1 v6Lto=1 wLevel=3
  c define: ALGO_SONDERFUNKTION2_USE_MIN_ANGLE=1
  c include: .\Config;.\SWSC_App;.\Generated;.\Hal;.\Protocol;.\AA;.\System;.\modules;.\dimming;.\Algorithm;.\Protocol
  memory RVCT4: ROM 0x12000000 size 0x7600
  memory RVCT9: RAM 0x18000000 size 0xc00
  scatter file: .\RTE\Device\TLD4020-4ET\tld40xx.sct
  group Config (external)
    ./Config/: lin_autoaddressing_cfg.c lin_autoaddressing_cfg.h
  group app
    ./SWSC_App/: LINApplication.c main.c lin_app.c
  group Generated
    ./Generated/: genLinConfig.c
  group Hal
    ./Hal/: lin_hal.c
  group Protocol
    ./Protocol/: lin_config.c lin_diag_raw.c lin_diag_tp.c lin_driver_api.c lin_main.c lin_master_task.c lin_slave_task.c
  group AA
    ./AA/: lin_autoaddressing.c
  group System
    ./System/: SystemControl.c SystemDerating.c SystemLinComm.c SystemLinDiag.c SystemMain.c SystemStatus.c SystemType.c
  group Modules
    ./modules/: ModuleAdc.c ModuleBattery.c ModuleClock.c ModuleFlash.c ModuleLed.c ModulePower.c ModuleTemperature.c ModuleWatchdog.c
  group dimming
    ./dimming/: BINARYSEARCH_U16.c Dimming_Calculate.c INTERPOLATE_U16_U16.c LookUp_U16_U16.c
  group Algorithm
    ./Algorithm/: Algorithm.c FloatLib.c
    ./Algorithm/AlgoRatioK_localfit/: AlgoRatioK_localfit.c
software components: CMSIS:CORE 6.1.0, Device:Config Wizard 1.1.0, Device:Lib:ADC11 1.2.0, Device:Lib:BOOTROM 1.0.0, Device:Lib:CPU 1.0.7, Device:Lib:GPIO 1.1.0, Device:Lib:ISR 1.0.6, Device:Lib:LDRV 1.2.0, Device:Lib:LIN 2.1.1, Device:Lib:MEM 1.0.4, Device:Lib:PMU 1.0.5, Device:Lib:SCU 1.1.1, Device:Startup 1.0.0
