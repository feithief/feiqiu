# Keil uVision project TLD4020_3ET_NVM_PROGRAMMING.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: TLD4020-3ET Infineon
  pack: Infineon.TLD40xx_DFP.2.0.1
  cpu: IRAM(0x18000000,0x0C00) IROM(0x12000000,0x7800) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: TLD4020_NVM_PROGRAMMING +hex
  AfterMake: findstr /C:"Total R" Listings\*.map
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=4
  c include: .\Algorithm;.\Code_CustomerDemo\Demo\App;.\Code_CustomerDemo\Demo\Generated;.\Code_CustomerDemo\Hal;.\Code_CustomerDemo\Protocol;.\lin_driver;.\modules;.\System;.\user;.\RTE\Device\TLD4020-3ET;.\Generated;.\dimming
  library: MicroLIB
  memory RVCT4: ROM 0x12000000 size 0x7600
  memory RVCT9: RAM 0x18000000 size 0xc00
  group user
    ./user/: lin_app.c lin_app.h
  group System
    ./System/: SystemControl.c SystemControl.h SystemDerating.c SystemDerating.h SystemLinComm.c SystemLinComm.h SystemLinDiag.c SystemLinDiag.h SystemMain.c SystemMain.h SystemStatus.c SystemStatus.h SystemType.h
  group modules
    ./modules/: ModuleAdc.c ModuleAdc.h ModuleBattery.c ModuleBattery.h ModuleClock.c ModuleClock.h ModuleFlash.c ModuleFlash.h ModuleLed.c ModuleLed.h ModuleTemperature.c ModuleTemperature.h ModuleDebug.c ModuleDebug.h Module1000TP_Test.h Module1000TP_Test.c
  group lin_driver
    ./lin_driver/: lin_config.c lin_config.h lin_diag_tp.c lin_diag_tp.h
  group Generated
    ./Generated/: genLinConfig.c genLinConfig.h
  group Hal
    ./Code_CustomerDemo/Hal/: lin_hal.c lin_hal.h
  group Protocol
    ./Code_CustomerDemo/Protocol/: lin_driver_api.c lin_main.c lin_slave_task.c
  group Algorithm
    ./Algorithm/: Algorithm.c Algorithm.h FloatLib.c FloatLib.h
  group app
    ./user/: main.c main.h
software components: CMSIS:CORE 6.1.0, Device:Config Wizard 1.1.0, Device:Lib:ADC11 1.0.2, Device:Lib:BOOTROM 1.0.0, Device:Lib:CPU 1.0.1, Device:Lib:GPIO 1.0.1, Device:Lib:ISR 1.0.2, Device:Lib:LDRV 1.0.2, Device:Lib:LIN 2.0.2, Device:Lib:MEM 1.0.1, Device:Lib:OSC 1.0.1, Device:Lib:PMU 1.0.1, Device:Lib:SCU 1.0.1, Device:Startup:Startup files 1.0.0
